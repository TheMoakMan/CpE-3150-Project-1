# Keil uVision project Project1.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LPC932A1 NXP
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM (0-0x1FF) CLOCK(12000000) MODP2
  output: Project1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Project1.a51 reg932.inc
